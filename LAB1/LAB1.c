/* ch01.c - LED高低位元交互閃爍程式 */
//==宣告區============================================
#include	<reg51.h>  	// 定義8051暫存器之標頭檔,P2-17~19
#define LED P1 	// 定義LED接至Port 2
void delay(int x);		// 宣告延遲函數 
//==主程式============================================
main()					// 主程式開始 
{	LED=0x3f;			// 初值=0011 1111
	while(1){	
		int i;
		for(i=0;i<4;i++){
			delay(30000);
			LED=(LED>>2);
		}
		for(i=0;i<6;i++){
			delay(30000);
			LED=~LED;
		}
		for(i=0;i<4;i++){
			delay(30000);
			LED=(LED<<2)| 0x03;
		}
	}
}						// 主程式結束 
//==延遲函數===========================================
void delay(int x)		// 延遲函數開始,x=延遲次數 
{	int i;				// 宣告整數變數i  
	for (i=0;i<x;i++);	// 計數x次  
}					// 延遲函數結束
